# Keil uVision project UCOS-1.uvprojx, settings and files
target UCOS-1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: UCOS-1 +hex
  AfterMake: fromelf --bin --output ..\OBJ\UCOS-1.bin ..\OBJ\UCOS-1.axf
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\tiza_drive\inc;..\sys_code\inc;..\tiza_drive\inc\fatfs
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_exti.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: readme.txt
  group tiza_scr
    ../tiza_drive/src/: tiza_driver.c tiza_adc.c tiza_spi.c tiza_debug.c tiza_selfdef.c tiza_can.c tiza_intflash.c tiza_RS232.c tiza_RS485.c tiza_sd.c sdio_sdcard.c tiza_rtc.c malloc.c tiza_l218dri.c tiza_l218opt.c tiza_ftp.c
    ../tiza_drive/src/fatfs/: exfuns.c ff.c diskio.c ccsbcs.c
  group sys_scr
    ../sys_code/src/: app_spiflash.c app_can.c app_intflash.c app_test..c app_l218.c app_protocol.c app_systask.c
  group tiza_inc
    ../tiza_drive/inc/: tiza_driver.h tiza_adc.h tiza_spi.h tiza_debug.h tiza_selfdef.h tiza_can.h tiza_intflash.h tiza_RS232.h tiza_RS485.h tiza_sd.h sdio_sdcard.h malloc.h tiza_rtc.h tiza_l218dri.h tiza_l218opt.h
    ../tiza_drive/inc/fatfs/: exfuns.h ff.h ffconf.h diskio.h integer.h
  group sys_inc
    ../sys_code/inc/: app_spiflash.h app_can.h app_intflash.h app_test.h app_l218.h app_protocol.h app_systask.h
